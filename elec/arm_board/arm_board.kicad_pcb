# Repository elkel53930/robosweep_twilight

File README.md:

# RoboSweep エージェント Twilight

[RoboSweepプレ大会](https://ntf.or.jp/robosweep/contest/contest2025/)で準優勝したチームからくり工房A:Macのエージェント(ロボット)Twilightのリポジトリです。

CADデータは[こちら](https://a360.co/4pVUIVw))

# ブロック図

## KiCad design elec/arm_board/arm_board.kicad_pcb

Parts:
C1, C2, C3, C6: CL10A475KO8NNNC; C_0603_1608Metric
C4, C7, C8, C10, C38, C41: CC0603KRX7R9BB104; C_0603_1608Metric
C5: RVT1A101M0505; CP_Elec_5x5.4
C26, C32: CL21A106KAYNNNE; C_0805_2012Metric
D1: WS2812B-2020; LED_WS2812B-2020_PLCC4_2.0x2.0mm
D2: D-060306G1/SS2/G1; LED_0603_1608Metric
D4: 1N5819WS; D_SOD-323
H1, H2, H3: M2; MountingHole_2.2mm_M2
J1, J2: PinHeader; PinHeader_1x03_P2.54mm_Vertical
J3: B6B-ZR; JST_ZH_B6B-ZR_1x06_P1.50mm_Vertical
J5: Fan motor; PinHeader_1x02_P2.54mm_Vertical
J12: B2B-XH-A(LF)(SN); JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical
J16: B4B-ZR(LF)(SN); JST_ZH_B4B-ZR_1x04_P1.50mm_Vertical
JP1: Switch 5V supply; PinHeader_1x02_P2.54mm_Vertical
Q5: DMT6008LFG; Diodes_PowerDI3333-8
R1: 25121WF500MT4E; D_2512_6332Metric
R2, R5: 0603WAF1002T5E; R_0603_1608Metric
R3, R4, R6, R7, R8, R9, R12: 0603WAF1001T5E; R_0603_1608Metric
U1: NA219AIDR; SOIC-8_3.9x4.9mm_P1.27mm
U3: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm
U4: AMS1117-5.0; SOT-223-3_TabPin2
U17: FT231XQ-R; QFN-20-1EP_4x4mm_P0.5mm_EP2.5x2.5mm
X1: CSTCE16M0V53-R0; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm

Connections:
+5V: C1.2, C2.2, C3.2, C6.1, C8.1, C10.1, C38.2, D1.4 (VDD), J3.6, J16.1, JP1.2 (B), R3.2, R4.2, R6.2, U1.5 (VS), U3.4 (VCC), U3.6 (VCC), U3.18 (AVCC), U17.12 (VCC)
+5VA: C5.1, C32.1, D4.2 (A), J1.2, J2.2, JP1.1 (A), U4.2 (VO)
+BATT: C26.2, D4.1 (K), J5.2, J12.1, R2.2, R5.2, U4.3 (VI)
/LED_SIG: D1.3 (DIN), U3.10 (PD6)
/MISO: J3.3, U3.16 (PB4)
/MOSI: J3.2, U3.15 (PB3)
/MOT_PWM: Q5.4 (G), R9.2, U3.1 (PD3)
/RESET: C7.2, J3.5, R6.1, U3.29 (~RESET/PC6)
/RX: R7.1, U17.17 (TXD)
/SCK: J3.4, U3.17 (PB5)
/SCL: R4.1, U1.4 (SCL), U3.28 (PC5)
/SDA: R3.1, U1.3 (SDA), U3.27 (PC4)
/SERVO_SIG1: J1.1, U3.12 (PB0)
/SERVO_SIG2: J2.1, U3.13 (PB1)
/TX: R8.1, U17.1 (RXD)
/USB+: J16.3, U17.8 (USBDP)
/USB-: J16.2, U17.9 (USBDM)
/VMON: R5.1, R12.2, U3.24 (PC1)
GND: C1.1, C2.1, C3.1, C4.1, C5.2, C6.2, C8.2, C10.2, C26.1, C32.2, C38.1, C41.1, D1.2 (VSS), D2.1 (K), J1.3, J2.3, J3.1, J12.2, J16.4, R1.1, R9.1, R12.1, U1.1 (A1), U1.2 (A0), U1.6 (GND), U1.7 (IN-), U3.3 (GND), U3.5 (GND), U3.21 (GND), U4.1 (GND), U17.3 (GND), U17.13 (GND), U17.21 (GND), X1.2
unnamed: D2.2 (A), R2.1
unnamed: J5.1, Q5.5 (D)
unnamed: Q5.1 (S), Q5.2 (S), Q5.3 (S), R1.2, U1.8 (IN+)
unnamed: C4.2, U3.20 (AREF)
unnamed: R7.2, U3.30 (PD0)
unnamed: R8.2, U3.31 (PD1)
unnamed: U3.7 (XTAL1/PB6), X1.3
unnamed: U3.8 (XTAL2/PB7), X1.1
unnamed: C41.2, U17.10 (3V3OUT), U17.11 (~RESET), U17.20 (VCCIO)
unnamed: C7.1, U17.18 (~DTR)

Notes on the sheet:
AVCC
VCC
4.7uF 16V X5R 1608 x3
USB I/F for RPi5
D13
電流検出抵抗とINA219の間はケルビン接続。 電流検出抵抗はTB67H450のRSピン直近に配置。
D12
ブートローダー書込み用
5V電源の切り替え。 SHORT : 内蔵レギュレータ OPEN : USBコネクタ
D11
Timer2はMOT_PWMからの PWM信号生成に使用するため、 Arduinoのtone()は使用不可。

Board: 2 copper layers, 39.0 x 31.0 mm, 42 parts (0 on the bottom side), 29 nets.

## KiCad design elec/main_board/main_board.kicad_pcb

Parts:
C1, C4, C5, C8, C11, C12, C21, C22: CC0603KRX7R9BB104; C_0603_1608Metric
C2, C6, C7, C13, C14, C18, C19: CL10A105KB8NNNC; C_0603_1608Metric
C3, C9, C10: CL21A106KAYNNNE; C_0805_2012Metric
C17, C20: CL10A106KP8NNNC; C_0603_1608Metric
D1, D2: D-060306G1/SS2/G1; LED_0603_1608Metric
D3: KT-0603R; LED_0603_1608Metric
H1, H2, H3, H4: M2.6 mounting hole; M2.6 Mounting Hole
J1, J2: Conn_01x02; PinHeader_1x02_P1.27mm_Vertical
J3, J6: 2.54mm PinHeader; PinHeader_2x05_P2.54mm_Vertical
J5, J8: B6B-ZR; JST_ZH_B6B-ZR_1x06_P1.50mm_Vertical
L1, L2: NR6045T100M; L_Changjiang_FNR6040S
Q1, Q2, Q3, Q4: IRLML6344; SOT-23
R1, R2, R14, R15, R16, R17: 0603WAF1002T5E; R_0603_1608Metric
R3, R4, R5, R23: 0603WAF1001T5E; R_0603_1608Metric
R6, R7, R8, R9: 0603WAF4700T5E; R_0603_1608Metric
R10, R11, R12, R13: 0603WAF1000T5E; R_0603_1608Metric
U1, U3, U4, U7, U8: ADCS7476; SOT-23-6
U2, U5: BD63573NUV; VSON-10-1EP_3x3mm_P0.5mm_EP1.2x2mm
U6: ESP32-S3-WROOM-1
U11: LSM6DSR; Bosch_LGA-14_3x2.5mm_P0.5mm

Connections:
+3V3: C1.1, C2.2, C4.1, C5.1, C6.2, C7.2, C8.2, C9.2, C11.1, C12.1, C13.2, C14.2, C18.1, C19.1, C20.2, C21.2, C22.2, D2.2 (A), D3.2 (A), J3.7, J3.8, J3.9, J3.10, J5.1, J8.1, R23.1, U1.1 (VDD), U2.1 (PS), U2.8 (VCC), U2.9 (PWM), U3.1 (VDD), U4.1 (VDD), U5.1 (PS), U5.8 (VCC), U5.9 (PWM), U6.2 (3V3), U7.1 (VDD), U8.1 (VDD), U11.5 (Vdd_IO), U11.8 (Vdd); also elsewhere on the board
+5V: C17.2, J6.7, J6.8, J6.9, J6.10; also elsewhere on the board
+BATT: C3.2, C10.2, R1.2, R2.2, U2.7 (VM), U5.7 (VM); also elsewhere on the board
/BATT_CS: U1.6 (~CS), U6.39 (IO1)
/CS_ENC_L: J5.6, U6.13 (USB_D-)
/CS_ENC_R: J8.6, U6.14 (USB_D+)
/CS_IMU: U6.20 (IO12), U11.12 (CS)
/CWCCW_L: U5.2 (INB), U6.16 (IO46)
/CWCCW_R: U2.2 (INB), U6.25 (IO48)
/LED_0: R4.1, U6.4 (IO4)
/LED_1: R5.1, U6.5 (IO5)
/LF_CS: U3.6 (~CS), U6.9 (IO16)
/LF_EN: Q1.1 (G), R14.2, U6.6 (IO6)
/LF_LED: J3.3, R10.2
/LF_PHTR: J3.4, R6.2, U3.3 (VIN)
/LS_CS: U4.6 (~CS), U6.8 (IO15)
/LS_EN: Q2.1 (G), R15.2, U6.7 (IO7)
/LS_LED: J3.1, R11.2
/LS_PHTR: J3.2, R7.2, U4.3 (VIN)
/PWM_L: U5.3 (INA), U6.15 (IO3)
/PWM_R: U2.3 (INA), U6.24 (IO47)
/RF_CS: U6.33 (IO40), U8.6 (~CS)
/RF_EN: Q4.1 (G), R17.2, U6.38 (IO2)
/RF_LED: J6.4, R13.2
/RF_PHTR: J6.3, R9.2, U8.3 (VIN)
/RS_CS: U6.34 (IO41), U7.6 (~CS)
/RS_EN: Q3.1 (G), R16.2, U6.35 (IO42)
/RS_LED: J6.2, R12.2
/RS_PHTR: J6.1, R8.2, U7.3 (VIN)
/SPI1_MISO: J5.4, J8.4, U6.11 (IO18)
/SPI1_MOSI: J5.3, J8.3, U6.10 (IO17)
/SPI1_SCK: J5.5, J8.5, U6.12 (IO8)
/SPI2_MISO: U1.5 (SDATA), U3.5 (SDATA), U4.5 (SDATA), U6.17 (IO9), U7.5 (SDATA), U8.5 (SDATA), U11.1 (SDO/SA0)
/SPI2_MOSI: U6.18 (IO10), U11.14 (SDA)
/SPI2_SCK: U1.4 (SCLK), U3.4 (SCLK), U4.4 (SCLK), U6.19 (IO11), U7.4 (SCLK), U8.4 (SCLK), U11.13 (SCL)
CHIP_PU: R23.2, U6.3 (EN); also elsewhere on the board
GND: C1.2, C2.1, C3.1, C4.2, C5.2, C6.1, C7.1, C8.1, C9.1, C10.1, C11.2, C12.2, C13.1, C14.1, C17.1, C18.2, C19.2, C20.1, C21.1, C22.1, D1.1 (K), J5.2, J8.2, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), R3.2, R6.1, R7.1, R8.1, R9.1, R14.1, R15.1, R16.1, R17.1, U1.2 (GND), U2.5 (PGND), U2.10 (GND), U2.11 (PGND), U3.2 (GND), U4.2 (GND), U5.5 (PGND), U5.10 (GND), U5.11 (PGND), U6.1 (GND), U6.40 (GND), U6.41 (GND), U7.2 (GND), U8.2 (GND), U11.2 (SDx), U11.3 (SCx), U11.6 (GND), U11.7 (GND); also elsewhere on the board
GPIO0: U6.27 (IO0); also elsewhere on the board
unnamed: D1.2 (A), R1.1
unnamed: D2.1 (K), R4.2
unnamed: D3.1 (K), R5.2
unnamed: J1.1, U2.6 (OUTA)
unnamed: J1.2, L1.2
unnamed: J2.1, U5.6 (OUTA)
unnamed: J2.2, L2.2
unnamed: Q1.3 (D), R10.1
unnamed: Q2.3 (D), R11.1
unnamed: Q3.3 (D), R12.1
unnamed: Q4.3 (D), R13.1
unnamed: R2.1, R3.1, U1.3 (VIN)
unnamed: L1.1, U2.4 (OUTB)
unnamed: L2.1, U5.4 (OUTB)
RXD0: U6.36 (RXD0); also elsewhere on the board
TXD0: U6.37 (TXD0); also elsewhere on the board

Notes on the sheet:
IMU
Wall sensor LEDs
PhTrs are mounted on the sub-board.
AS5047 SPI mode = 1 (Latch at fall edges)
Indicators
Processor
LEDs are mounted on the sub-board.
Battery Voltage measurement
Sensor sub board connector
LSM6DSR SPI mode = 3 (Latch at rise edges)
Motor drivers
Wall sensor PhTrs
Encoders
↑ FRONT
ADCS7476 SPI mode = 3 (Latch at rise edges)

Parts:
BT1: 1000mAh LiPo 2S; Battery_Connector
C23, C24, C25, C33, C34, C35, C38, C39, C40, C41: CC0603KRX7R9BB104; C_0603_1608Metric
C26, C27, C32: CL21A106KAYNNNE; C_0805_2012Metric
C28, C29, C30, C31: CL10A106KP8NNNC; C_0603_1608Metric
C36, C37: CL10A105KB8NNNC; C_0603_1608Metric
D4: 1N5819WS; D_SOD-323
D5: KT-0603R; LED_0603_1608Metric
J9: MJ-179PH; PJ-002A
J10: Conn_01x02; JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical
J11, J12: B2B-XH-A(LF)(SN); JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical
J16: B4B-ZR(LF)(SN); JST_ZH_B4B-ZR_1x04_P1.50mm_Vertical
Q5, Q6: DMT6008LFG; Diodes_PowerDI3333-8
Q7, Q8: DTC114E; SOT-723
R18, R21, R22: 0603WAF1001T5E; R_0603_1608Metric
R19: 0603WAF3300T5E; R_0603_1608Metric
R20: 0603WAF100JT5E; R_0603_1608Metric
U12: OKL-T/6-W12N-C; OKL-T&slash_6-W12N-C_MUR
U13: XC6221B332MR; SOT-23-5
U14, U16: LM74700QDBVRQ1; SOT-23-6
U15: MCP73213T-A6SI/MF; DFN-10-1EP_3x3mm_P0.5mm_EP1.58x2.35mm
U17: FT231XQ-R; QFN-20-1EP_4x4mm_P0.5mm_EP2.5x2.5mm

Connections:
+3V3: C31.2, U13.5 (VOUT); also elsewhere on the board
+5V: C27.1, C28.2, C29.2, C30.2, C32.1, C38.2, D4.2 (A), J10.1, J16.1, U12.4 (Vout), U12.5 (Sense), U13.1 (VIN), U13.3 (CE), U17.12 (VCC); also elsewhere on the board
+BATT: C25.2, C26.2, C35.2, D4.1 (K), J11.1, J12.1, Q5.5 (D), Q6.5 (D), U12.2 (Vin), U14.4 (CATHODE), U16.4 (CATHODE); also elsewhere on the board
/Power/DTR: Q7.1 (B), Q8.2 (E), U17.18 (~DTR)
/Power/EXT_PWR: C23.2, C24.2, C36.2, D5.2 (A), J9.1, Q5.1 (S), Q5.2 (S), Q5.3 (S), U14.3 (EN), U14.6 (ANODE), U15.1 (VDD), U15.2 (VDD)
/Power/RTS: Q7.2 (E), Q8.1 (B), U17.19 (~RTS)
/Power/USB+: J16.3, U17.8 (USBDP)
/Power/USB-: J16.2, U17.9 (USBDM)
CHIP_PU: C39.2, Q7.3 (C); also elsewhere on the board
GND: BT1.2 (-), C23.1, C25.1, C26.1, C27.2, C28.1, C29.1, C30.1, C31.1, C32.2, C33.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, J9.2, J9.3, J10.2, J11.2, J12.2, J16.4, R20.2, R22.2, U12.1 (ON/OFF), U12.3 (GND), U12.7 (GND), U13.2 (GND), U14.2 (GND), U15.8 (VSS), U15.9 (VSS), U15.11 (EP), U16.2 (GND), U17.3 (GND), U17.13 (GND), U17.21 (GND); also elsewhere on the board
GPIO0: C40.2, Q8.3 (C); also elsewhere on the board
unnamed: BT1.1 (+), C33.2, C34.2, C37.2, Q6.1 (S), Q6.2 (S), Q6.3 (S), U15.3 (VBAT), U15.4 (VBAT), U16.3 (EN), U16.6 (ANODE)
unnamed: D5.1 (K), R21.2
unnamed: Q5.4 (G), U14.5 (GATE)
unnamed: Q6.4 (G), U16.5 (GATE)
unnamed: R18.2, R19.1
unnamed: R19.2, R20.1
unnamed: R18.1, U12.6 (Trim)
unnamed: C24.1, U14.1 (VCAP)
unnamed: R22.1, U15.10 (PROG)
unnamed: R21.1, U15.7 (STAT)
unnamed: C34.1, U16.1 (VCAP)
unnamed: C41.2, U17.10 (3V3OUT), U17.11 (~RESET), U17.20 (VCCIO)
RXD0: U17.17 (TXD); also elsewhere on the board
TXD0: U17.1 (RXD); also elsewhere on the board

Notes on the sheet:
Charge current = 1100mA
Power supply for RPi5 5V Max5A
5V Max6A
Power management
Power supply
USB I/F for RPi5
USB-Serial I/F

Board: 2 copper layers, 84.0 x 114.0 mm, 108 parts (0 on the bottom side), 71 nets.

## KiCad design elec/sub_boards/sub_boards.kicad_pcb

Parts:
C15: CC0603KRX7R9BB104; C_0402_1005Metric
C16: CL05B104KO5NNNC; C_0402_1005Metric
D1, D2: SFH4550
D3, D4: SFH4550; SFH4550_Mirror
H1, H2: MountingHole; M2.6 Mounting Hole
H3, H4, H5, H6: M2 mounting hole; MountingHole_2.2mm_M2
J1: Raspberry_Pi_5; PinSocket_2x20_P2.54mm_Vertical
J2: PinSocket_1x07_P2.54mm_Vertical
J3, J4: 2.54mm PinHeader; PinHeader_2x05_P2.54mm_Vertical
J5, J6: EncSide; EncoderPad
Q1, Q2: ST-1KL3A
Q3, Q4: ST-1KL3A; ST-1KL3A_Mirror
SW1, SW2, SW3, SW4: TVBP06-B043CB-B; SW_PUSH_1P1T_6x3.5mm_H4.3_APEM_MJTP1243
U9, U10: AS5047D; TSSOP-14_4.4x5mm_P0.65mm

Connections:
+3.3V: J1.1 (3V3), J2.2 (VCC)
/BTN_DOWN: J1.3 (SDA_I2C1/GPIO02), SW1.1
/BTN_LEFT: J1.7 (GPCLK0/GPIO04), SW4.1
/BTN_RIGHT: J1.11 (GPIO17/SPI1_~CE1), SW3.1
/BTN_UP: J1.5 (SCL_I2C1/GPIO03), SW2.1
/CS: J1.24 (~CE0_SPI0/GPIO08), J2.7 (CS)
/DC: J1.18 (GPIO24/SDIO_DAT0), J2.6 (DC)
/LF_LED: D1.1 (K), J3.3
/LF_PHTR: J3.4, Q1.1 (E)
/LS_LED: D2.1 (K), J3.1
/LS_PHTR: J3.2, Q2.1 (E)
/MOSI: J1.19 (MOSI_SPI0/GPIO10), J2.4 (SDA)
/RES: J1.22 (GPIO25/SDIO_DAT1), J2.5 (RES)
/RF_LED: D4.1 (K), J4.4
/RF_PHTR: J4.3, Q4.1 (E)
/RS_LED: D3.1 (K), J4.2
/RS_PHTR: J4.1, Q3.1 (E)
/SCLK: J1.23 (SCLK_SPI0/GPIO11), J2.3 (SCL)
/SEN_3V3: J3.7, J3.8, J3.9, J3.10, Q1.2 (C), Q2.2 (C), Q3.2 (C), Q4.2 (C)
/SEN_5V: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), J4.7, J4.8, J4.9, J4.10
GND: J1.6 (GND), J1.9 (GND), J1.14 (GND), J1.20 (GND), J1.25 (GND), J1.30 (GND), J1.34 (GND), J1.39 (GND), J2.1 (GND), SW1.2, SW2.2, SW3.2, SW4.2
unnamed: C15.2, J5.1, U9.12 (VDD3V3)
unnamed: C15.1, J5.2, U9.5 (TST), U9.13 (GND)
unnamed: J5.3, U9.4 (MOSI)
unnamed: J5.4, U9.3 (MISO)
unnamed: J5.5, U9.2 (CLK)
unnamed: J5.6, U9.1 (~CS)
unnamed: C16.2, J6.1, U10.12 (VDD3V3)
unnamed: C16.1, J6.2, U10.5 (TST), U10.13 (GND)
unnamed: J6.3, U10.4 (MOSI)
unnamed: J6.4, U10.3 (MISO)
unnamed: J6.5, U10.2 (CLK)
unnamed: J6.6, U10.1 (~CS)

Notes on the sheet:
Encoders
